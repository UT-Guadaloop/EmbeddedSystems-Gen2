<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/freertos_builds_MSP432E411Y_BGAEVM_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
