# IAR project tirtos_builds_MSP432E411Y_BGAEVM_release.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: tirtos_builds_MSP432E411Y_BGAEVM_release.ipcf
  group TIRTOS kernel project/Configuration files
    ../: release.cfg
