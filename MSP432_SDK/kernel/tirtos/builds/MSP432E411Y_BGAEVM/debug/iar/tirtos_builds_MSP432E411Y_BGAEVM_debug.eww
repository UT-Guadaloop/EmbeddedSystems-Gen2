<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/tirtos_builds_MSP432E411Y_BGAEVM_debug.ewp</path>
  </project>
  <batchBuild/>
</workspace>
