# IAR project i2c_mastermode_repeatedstart_transfer_MSP_EXP432E401Y_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: i2c_mastermode_repeatedstart_transfer_MSP_EXP432E401Y_nortos_iar.ipcf
