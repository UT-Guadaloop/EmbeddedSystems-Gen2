# IAR project adc0_dcmp6_highband_alwaysinterrupt_MSP_EXP432E401Y_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: adc0_dcmp6_highband_alwaysinterrupt_MSP_EXP432E401Y_nortos_iar.ipcf
