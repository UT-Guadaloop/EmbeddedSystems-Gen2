<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/i2c_mastermode_fifocpu_transfer_MSP_EXP432E401Y_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>