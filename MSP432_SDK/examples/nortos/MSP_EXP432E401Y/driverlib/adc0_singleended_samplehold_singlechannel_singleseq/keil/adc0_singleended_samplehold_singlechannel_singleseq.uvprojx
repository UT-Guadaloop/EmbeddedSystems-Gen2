# Keil uVision project adc0_singleended_samplehold_singlechannel_singleseq.uvprojx, settings and files
target adc0_singleended_samplehold_singlechannel_singleseq (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.0_eng
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: adc0_singleended_samplehold_singlechannel_singleseq
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../../../../../source ; ../../../../../../source/third_party/CMSIS/Include/
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ../: adc0_singleended_samplehold_singlechannel_singleseq.c system_msp432e401y.c uartstdio.c
    ./: startup_msp432e401y_uvision.s
  group Library
    ../../../../../../source/ti/devices/msp432e4/driverlib/lib/keil/m4f/: msp432e4_driverlib.a
software components: CMSIS:CORE 5.0.1
