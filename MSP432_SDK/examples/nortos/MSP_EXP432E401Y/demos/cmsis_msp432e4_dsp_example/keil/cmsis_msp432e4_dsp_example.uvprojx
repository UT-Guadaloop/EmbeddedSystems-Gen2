# Keil uVision project cmsis_msp432e4_dsp_example.uvprojx, settings and files
target cmsis_msp432e4_dsp_example (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.1
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cmsis_msp432e4_dsp_example
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Include/;../../../../../../source/third_party/CMSIS/DSP_Lib/Include/
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ../: cmsis_msp432e4_dsp_example.c system_msp432e401y.c uartstdio.c
    ./: startup_msp432e401y_uvision.s
  group Library
    ../../../../../../source/ti/devices/msp432e4/driverlib/lib/keil/m4f/: msp432e4_driverlib.a
    ../../../../../../source/third_party/CMSIS/DSP_Lib/lib/keil/m4f/: arm_cortexM4lf_math.a
software components: CMSIS:CORE 5.0.1
