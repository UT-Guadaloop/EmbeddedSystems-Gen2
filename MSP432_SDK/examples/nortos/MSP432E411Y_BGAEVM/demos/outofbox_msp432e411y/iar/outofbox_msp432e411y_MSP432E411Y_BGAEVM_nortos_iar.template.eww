<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/outofbox_msp432e411y_MSP432E411Y_BGAEVM_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>