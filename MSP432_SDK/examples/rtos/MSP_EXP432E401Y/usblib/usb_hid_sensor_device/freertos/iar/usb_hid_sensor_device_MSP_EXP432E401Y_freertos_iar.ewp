# IAR project usb_hid_sensor_device_MSP_EXP432E401Y_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: usb_hid_sensor_device_MSP_EXP432E401Y_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
