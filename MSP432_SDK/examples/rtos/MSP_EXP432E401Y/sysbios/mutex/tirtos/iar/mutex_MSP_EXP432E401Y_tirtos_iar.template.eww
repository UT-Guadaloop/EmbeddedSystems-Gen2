<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/mutex_MSP_EXP432E401Y_tirtos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>