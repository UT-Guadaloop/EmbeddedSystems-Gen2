<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/gpiointerrupt_MSP_EXP432E401Y_freertos_iar.ewp</path>
    </project>
    <project>
        <path>$SIMPLELINK_MSP432E4_SDK_INSTALL_DIR$/kernel/freertos/builds/MSP_EXP432E401Y/release/iar/freertos_builds_MSP_EXP432E401Y_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>